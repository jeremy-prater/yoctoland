require u-boot-common.inc
require u-boot-tools.inc

SRCREV = "v2020.04"