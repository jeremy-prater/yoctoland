FILESEXTRAPATHS_prepend := "${THISDIR}/swupdate:"
SRC_URI += "file://defconfig"