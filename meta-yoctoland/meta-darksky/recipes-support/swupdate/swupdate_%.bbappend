FILESEXTRAPATHS:prepend := "${THISDIR}/swupdate:"
SRC_URI += "file://defconfig"