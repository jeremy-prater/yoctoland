#LINUX_VERSION = "5.3"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://boot.cmd"